LLAMA_CPP_CUDA_INC = ""
LLAMA_CPP_CUDA_INC:cuda = "llama-cpp-cuda.inc"
require ${LLAMA_CPP_CUDA_INC}
