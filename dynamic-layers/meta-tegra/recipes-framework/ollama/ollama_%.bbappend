OLLAMA_CUDA_INC = ""
OLLAMA_CUDA_INC:cuda = "ollama-cuda.inc"
require ${OLLAMA_CUDA_INC}
