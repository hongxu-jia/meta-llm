require ol-qwen3.5.inc

LIC_FILES_CHKSUM = "file://sha256-${LICENSE_SHA256};md5=f5951e2483da98835651f9a40644f65b"
MODEL_TAG = "2b"

LICENSE_SHA256 = "9be69ef463066202c1b1bd299aaf42bad370a01ba4b40d293617859720776c17"
MANIFEST_SHA256 = "324d162be6ca5629ae4517c8710434d0bd2d665bc94dbad46e9af8fbf8a2f0df"
IMAGE_JSON_SHA256 = "ee043a99abe5e8317272712ed08ee2993af1f7930d69aefa3eba562cdc2822bd"
MODEL_SHA256 = "b709d81508a078a686961de6ca07a953b895d9b286c46e17f00fb267f4f2d297"
