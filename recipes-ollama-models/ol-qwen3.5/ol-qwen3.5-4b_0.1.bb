require ol-qwen3.5.inc

LIC_FILES_CHKSUM = "file://sha256-${LICENSE_SHA256};md5=74a71048faae6970e5803fc65b388bf1"
MODEL_TAG = "4b"

LICENSE_SHA256 = "7339fa418c9ad3e8e12e74ad0fd26a9cc4be8703f9c110728a992b193be85cb2"
MANIFEST_SHA256 = "2a654d98e6fba55d452b7043684e9b57a947e393bbffa62485a7aac05ee4eefd"
IMAGE_JSON_SHA256 = "de9fed2251b37295b763727a59ca35cf5cfe5c7379bc3e2104b2ce3c145aa887"
MODEL_SHA256 = "81fb60c7daa80fc1123380b98970b320ae233409f0f71a72ed7b9b0d62f40490"
