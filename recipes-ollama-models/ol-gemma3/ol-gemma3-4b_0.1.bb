require ol-gemma3.inc

MODEL_TAG = "4b"

MANIFEST_SHA256 = "a2af6cc3eb7fa8be8504abaf9b04e88f17a119ec3f04a3addf55f92841195f5a"
IMAGE_JSON_SHA256 = "b6ae5839783f2ba248e65e4b960ab15f9c4b7118db285827dba6cba9754759e2"
MODEL_SHA256 = "aeda25e63ebd698fab8638ffb778e68bed908b960d39d0becc650fa981609d25"

