require ol-gemma3.inc

MODEL_TAG = "1b"

MANIFEST_SHA256 = "8648f39daa8fbf5b18c7b4e6a8fb4990c692751d49917417b8842ca5758e7ffc"
IMAGE_JSON_SHA256 = "120007c81bf8b4eb54e896a4a3e5ff9949f124b0ea42295277c8523f7fa9c7f6"
MODEL_SHA256 = "7cd4618c1faf8b7233c6c906dac1694b6a47684b37b8895d470ac688520b9c01"
